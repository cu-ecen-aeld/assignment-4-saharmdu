## base_external/Config.in
```kconfig
menu "Project base packages"
source "package/aesd-assignments/Config.in"
endmenu
```
